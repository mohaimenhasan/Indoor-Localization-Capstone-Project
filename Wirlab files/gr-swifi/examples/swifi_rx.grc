<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>swifi_rx</value></param>
<param><key>title</key><value>SWiFi RX</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter_2</value></param>
<param><key>value</key><value>swifi.ofdm_phy_header_parser("frame_len", "phy")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>value</key><value>swifi.wifi_constellation_bpsk()</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>source</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>payload_stream</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>header_stream</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>2.412e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sampling Rate</value></param>
<param><key>value</key><value>20e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha</value></param>
<param><key>value</key><value>0.15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta</value></param>
<param><key>label</key><value>Beta</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>F</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>A</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nskip</value></param>
<param><key>label</key><value>Skip</value></param>
<param><key>value</key><value>20000000</value></param>
<param><key>type</key><value>long</value></param>
<param><key>short_id</key><value>n</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>payload_stream</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>swifi_ofdm_chan_est</key>
<param><key>id</key><value>swifi_ofdm_chan_est_0</value></param>
<param><key>method</key><value>0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>sync_symbols</key><value>((0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))</value></param>
<param><key>set_frame_length</key><value>1</value></param>
<param><key>len_tag_key</key><value>"frame_len"</value></param>
<param><key>fixed_length</key><value>3</value></param>
<param><key>channel_states_tag_key</key><value>"channel_states"</value></param>
<param><key>copy_sync_symbols</key><value>False</value></param>
<param><key>alpha</key><value>0.5</value></param>
</block>
<block>
<key>swifi_ofdm_equalizer</key>
<param><key>id</key><value>swifi_ofdm_equalizer_1</value></param>
<param><key>method</key><value>equalization_method</value></param>
<param><key>foc_enabled</key><value>False</value></param>
<param><key>set_constellation</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk()</value></param>
<param><key>channel_states_tag_key</key><value>"channel_states"</value></param>
<param><key>propagate_channel_states</key><value>True</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>debug_file</key><value>""</value></param>
</block>
<block>
<key>digital_packet_headerparser_b</key>
<param><key>id</key><value>digital_packet_headerparser_b_0_0</value></param>
<param><key>header_formatter</key><value>header_formatter_2.base()</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>swifi_wifi_conv_decoder</key>
<param><key>id</key><value>swifi_wifi_conv_decoder_0_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>blocksize</key><value>24</value></param>
<param><key>rate</key><value>-1</value></param>
</block>
<block>
<key>swifi_interleaver</key>
<param><key>id</key><value>swifi_interleaver_0_0</value></param>
<param><key>is_interleaver</key><value>False</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>11</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ff</value></param>
<param><key>label</key><value>Frame Filter</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>swifi_ofdm_equalizer</key>
<param><key>id</key><value>swifi_ofdm_equalizer_0</value></param>
<param><key>method</key><value>equalization_method</value></param>
<param><key>foc_enabled</key><value>False</value></param>
<param><key>set_constellation</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>constellation</key><value>None</value></param>
<param><key>channel_states_tag_key</key><value>"channel_states"</value></param>
<param><key>propagate_channel_states</key><value>False</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>debug_file</key><value>""</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>48</value></param>
</block>
<block>
<key>swifi_header_payload_demux</key>
<param><key>id</key><value>swifi_header_payload_demux_0</value></param>
<param><key>header_len</key><value>3</value></param>
<param><key>items_per_symbol</key><value>64</value></param>
<param><key>guard_interval</key><value>16</value></param>
<param><key>length_tag_key</key><value>"frame_len"</value></param>
<param><key>trigger_tag_key</key><value>"trigger"</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>swifi_ofdm_frame_sync</key>
<param><key>id</key><value>swifi_ofdm_frame_sync_0</value></param>
<param><key>short_threshold</key><value>0.9</value></param>
<param><key>min_short_plateau_len</key><value>64</value></param>
<param><key>long_threshold</key><value>0.4</value></param>
<param><key>drop_ratio_threshold</key><value>0.2</value></param>
<param><key>avg_alpha</key><value>0.05</value></param>
<param><key>trigger_method</key><value>0</value></param>
<param><key>trigger_tag_key</key><value>"trigger"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dump_filename</value></param>
<param><key>label</key><value>Dump Filename</value></param>
<param><key>value</key><value>"&lt;&lt;stdout&gt;&gt;"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>O</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>equalization_method</value></param>
<param><key>label</key><value>Equalization Method</value></param>
<param><key>value</key><value>ppt_dd</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>e</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>header_stream</value></param>
</block>
<block>
<key>swifi_scrambler</key>
<param><key>id</key><value>swifi_scrambler_0</value></param>
<param><key>is_scrambler</key><value>False</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>swifi_payload_parser</key>
<param><key>id</key><value>swifi_payload_parser_0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>dump_filename</key><value>dump_filename</value></param>
<param><key>dump_format</key><value>"xml"</value></param>
<param><key>filter_string</key><value>ff</value></param>
<param><key>is_print_raw</key><value>True</value></param>
</block>
<block>
<key>swifi_sample_marker</key>
<param><key>id</key><value>swifi_sample_marker_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>header_mod.base()</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>48</value></param>
</block>
<block>
<key>swifi_constellation_decoder</key>
<param><key>id</key><value>swifi_constellation_decoder_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>constellation</key><value>None</value></param>
</block>
<block>
<key>swifi_bit_unpacker</key>
<param><key>id</key><value>swifi_bit_unpacker_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>bpsc</key><value>1</value></param>
</block>
<block>
<key>swifi_interleaver</key>
<param><key>id</key><value>swifi_interleaver_0</value></param>
<param><key>is_interleaver</key><value>False</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>11</value></param>
</block>
<block>
<key>swifi_bit_inserter</key>
<param><key>id</key><value>swifi_bit_inserter_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>11</value></param>
</block>
<block>
<key>swifi_wifi_conv_decoder</key>
<param><key>id</key><value>swifi_wifi_conv_decoder_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>blocksize</key><value>0</value></param>
<param><key>rate</key><value>-1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>antenna</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>source</value></param>
</block>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>swifi_ofdm_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>swifi_ofdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_ofdm_equalizer_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_0_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>swifi_ofdm_chan_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_ofdm_equalizer_1</source_block_id><sink_block_id>blocks_vector_to_stream_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_ofdm_chan_est_0</source_block_id><sink_block_id>swifi_ofdm_equalizer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_inserter_0</source_block_id><sink_block_id>swifi_wifi_conv_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>swifi_payload_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_scrambler_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0</source_block_id><sink_block_id>swifi_scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_unpacker_0</source_block_id><sink_block_id>swifi_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_constellation_decoder_0</source_block_id><sink_block_id>swifi_bit_unpacker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_interleaver_0</source_block_id><sink_block_id>swifi_bit_inserter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_interleaver_0_0</source_block_id><sink_block_id>swifi_wifi_conv_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headerparser_b_0_0</source_block_id><sink_block_id>swifi_header_payload_demux_0</sink_block_id><source_key>header_data</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>digital_packet_headerparser_b_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>swifi_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_sample_marker_0</source_block_id><sink_block_id>swifi_constellation_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_0</source_block_id><sink_block_id>swifi_sample_marker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_ofdm_frame_sync_0</source_block_id><sink_block_id>swifi_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_header_payload_demux_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_header_payload_demux_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
