<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>File Name</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>F</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_secs</value></param>
<param><key>label</key><value>tx secs</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>t</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_sec_frac</value></param>
<param><key>label</key><value>tx sec frac</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>q</value></param>
</block>
<block>
<key>swifi_tx_time_tag_adder</key>
<param><key>id</key><value>swifi_tx_time_tag_adder_0</value></param>
<param><key>full_secs</key><value>tx_secs</value></param>
<param><key>frac_sec</key><value>tx_sec_frac</value></param>
<param><key>length_tag_key</key><value>"length"</value></param>
<param><key>length</key><value>length</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>length</value></param>
<param><key>label</key><value>length</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>l</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>center frequency</value></param>
<param><key>value</key><value>2412e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>label</key><value>ip address</value></param>
<param><key>value</key><value>addr=192.168.10.5</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>addr</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>20e6</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>len_tag_name</key><value>"length"</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>tx_timed_from_file</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<connection><source_block_id>swifi_tx_time_tag_adder_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>swifi_tx_time_tag_adder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
