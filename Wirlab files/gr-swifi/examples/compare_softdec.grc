<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c</value></param>
<param><key>value</key><value>swifi.wifi_constellation_64qam()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>swifi_bitmetrics_inserter</key>
<param><key>id</key><value>swifi_bitmetrics_inserter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>11</value></param>
</block>
<block>
<key>swifi_bitmetrics_computer</key>
<param><key>id</key><value>swifi_bitmetrics_computer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"signal"</value></param>
<param><key>constellation</key><value>c.base()</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>(1, -0.01, 0.2, -0.3, 0.4, -0.5, 0.6, -0.7)</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>swifi_bitmetrics_interleaver</key>
<param><key>id</key><value>swifi_bitmetrics_interleaver_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>is_interleaver</key><value>True</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>11</value></param>
</block>
<block>
<key>digitalcomm_text_sink_X</key>
<param><key>id</key><value>digitalcomm_text_sink_X_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>filename</key><value>&lt;&lt;stdout&gt;&gt;</value></param>
<param><key>append</key><value>False</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>auto_format</key><value>True</value></param>
<param><key>custom_format</key><value></value></param>
</block>
<block>
<key>swifi_chunks_to_symbols</key>
<param><key>id</key><value>swifi_chunks_to_symbols_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"signal"</value></param>
<param><key>points</key><value>c.points()</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>swifi_constellation_decoder</key>
<param><key>id</key><value>swifi_constellation_decoder_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"signal"</value></param>
<param><key>constellation</key><value>c.base()</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digitalcomm_spread_sheet</key>
<param><key>id</key><value>digitalcomm_spread_sheet_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>type1</key><value>byte</value></param>
<param><key>type2</key><value>byte</value></param>
<param><key>type3</key><value>complex</value></param>
<param><key>type4</key><value>complex</value></param>
<param><key>type5</key><value>complex</value></param>
<param><key>type6</key><value>complex</value></param>
<param><key>type7</key><value>complex</value></param>
<param><key>type8</key><value>complex</value></param>
<param><key>type9</key><value>complex</value></param>
<param><key>type10</key><value>complex</value></param>
<param><key>type11</key><value>complex</value></param>
<param><key>type12</key><value>complex</value></param>
<param><key>filename</key><value>&lt;&lt;stdout&gt;&gt;</value></param>
<param><key>append</key><value>False</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>auto_format</key><value>True</value></param>
<param><key>custom_format_1</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_2</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_3</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_4</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_5</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_6</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_7</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_8</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_9</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_10</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_11</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
<param><key>custom_format_12</key><value>"char=%c,int=%d,float=%f,complex=(%f,%f),hex=%x"</value></param>
</block>
<block>
<key>swifi_wifi_conv_encoder</key>
<param><key>id</key><value>swifi_wifi_conv_encoder_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>blocksize</key><value>24</value></param>
</block>
<block>
<key>swifi_wifi_conv_decoder</key>
<param><key>id</key><value>swifi_wifi_conv_decoder_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>blocksize</key><value>24</value></param>
<param><key>rate</key><value>15</value></param>
</block>
<block>
<key>swifi_bit_packer</key>
<param><key>id</key><value>swifi_bit_packer_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>bpsc</key><value>c.bits_per_symbol()</value></param>
</block>
<block>
<key>swifi_bit_unpacker</key>
<param><key>id</key><value>swifi_bit_unpacker_0</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>bpsc</key><value>c.bits_per_symbol()</value></param>
</block>
<block>
<key>swifi_bitmetrics_computer</key>
<param><key>id</key><value>swifi_bitmetrics_computer_1</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>phy_tag_key</key><value>"signal"</value></param>
<param><key>constellation</key><value>c.base()</value></param>
</block>
<block>
<key>digitalcomm_text_sink_X</key>
<param><key>id</key><value>digitalcomm_text_sink_X_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filename</key><value>&lt;&lt;stdout&gt;&gt;</value></param>
<param><key>append</key><value>False</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>auto_format</key><value>True</value></param>
<param><key>custom_format</key><value></value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>swifi_wifi_conv_soft_decoder</key>
<param><key>id</key><value>swifi_wifi_conv_soft_decoder_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>blocksize</key><value>24</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>digitalcomm_text_sink_X</key>
<param><key>id</key><value>digitalcomm_text_sink_X_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filename</key><value>&lt;&lt;stdout&gt;&gt;</value></param>
<param><key>append</key><value>False</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>auto_format</key><value>True</value></param>
<param><key>custom_format</key><value></value></param>
</block>
<block>
<key>digitalcomm_text_sink_X</key>
<param><key>id</key><value>digitalcomm_text_sink_X_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filename</key><value>&lt;&lt;stdout&gt;&gt;</value></param>
<param><key>append</key><value>False</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>auto_format</key><value>True</value></param>
<param><key>custom_format</key><value></value></param>
</block>
<block>
<key>swifi_bitmetrics_inserter</key>
<param><key>id</key><value>swifi_bitmetrics_inserter_1</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>swifi_bitmetrics_interleaver</key>
<param><key>id</key><value>swifi_bitmetrics_interleaver_1</value></param>
<param><key>is_interleaver</key><value>False</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>swifi_interleaver</key>
<param><key>id</key><value>swifi_interleaver_0_0</value></param>
<param><key>is_interleaver</key><value>False</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>swifi_bit_inserter</key>
<param><key>id</key><value>swifi_bit_inserter_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>swifi_bit_stealer</key>
<param><key>id</key><value>swifi_bit_stealer_0</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>swifi_interleaver</key>
<param><key>id</key><value>swifi_interleaver_0</value></param>
<param><key>is_interleaver</key><value>True</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>phy_tag_key</key><value>"phy"</value></param>
<param><key>rate</key><value>12</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0, 1, 1, 0)*6*12</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.3</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>compare_softdec</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<connection><source_block_id>swifi_bitmetrics_inserter_0</source_block_id><sink_block_id>digitalcomm_text_sink_X_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bitmetrics_interleaver_0</source_block_id><sink_block_id>swifi_bitmetrics_inserter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bitmetrics_computer_0</source_block_id><sink_block_id>swifi_bitmetrics_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>swifi_bitmetrics_computer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_packer_0</source_block_id><sink_block_id>swifi_chunks_to_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_interleaver_0</source_block_id><sink_block_id>swifi_bit_packer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>swifi_chunks_to_symbols_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>swifi_constellation_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_constellation_decoder_0</source_block_id><sink_block_id>swifi_bit_unpacker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_unpacker_0</source_block_id><sink_block_id>swifi_interleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0</source_block_id><sink_block_id>digitalcomm_text_sink_X_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>swifi_wifi_conv_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_encoder_0</source_block_id><sink_block_id>swifi_bit_stealer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_inserter_0</source_block_id><sink_block_id>swifi_wifi_conv_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0_0</source_block_id><sink_block_id>digitalcomm_spread_sheet_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_soft_decoder_0</source_block_id><sink_block_id>blocks_xor_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_xor_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>digitalcomm_spread_sheet_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>swifi_bitmetrics_computer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bitmetrics_computer_1</source_block_id><sink_block_id>swifi_bitmetrics_interleaver_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_soft_decoder_0</source_block_id><sink_block_id>digitalcomm_text_sink_X_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_interleaver_0_0</source_block_id><sink_block_id>swifi_bit_inserter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bit_stealer_0</source_block_id><sink_block_id>swifi_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bitmetrics_inserter_1</source_block_id><sink_block_id>swifi_wifi_conv_soft_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_soft_decoder_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_wifi_conv_decoder_0</source_block_id><sink_block_id>digitalcomm_text_sink_X_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>swifi_bitmetrics_interleaver_1</source_block_id><sink_block_id>swifi_bitmetrics_inserter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
