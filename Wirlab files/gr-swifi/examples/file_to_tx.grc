<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>20e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>2.462e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>TX Antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>A</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>from_file</value></param>
<param><key>label</key><value>File to Read from</value></param>
<param><key>value</key><value>tx.32fc</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>from_file</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>file_to_tx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
